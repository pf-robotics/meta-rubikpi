PACKAGECONFIG:append = " shell-kiosk"
FILES:${PN} += "${libdir}/weston/kiosk-shell.so"
