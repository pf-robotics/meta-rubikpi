# The upstream gflags repo renamed master -> main
SRC_URI = "git://github.com/gflags/gflags.git;branch=main;protocol=https"
