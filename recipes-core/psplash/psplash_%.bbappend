# PSplash configuration for RubikPi

# Use custom logo
SPLASH_IMAGES = "file://psplash-rubikpi-img.png;outsuffix=default"

# Custom colors
PSPLASH_BACKGROUND_COLOR ?= "0x00,0x00,0x00"
PSPLASH_STARTUP_BAR_COLOR ?= "0x00,0x96,0xC8"
